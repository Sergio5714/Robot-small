# Keil uVision project SmallRobot.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SmallRobot +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Board;.\HAL;.\Robot
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c
  group HAL
    ./HAL/: STM32F4_GPIO.c STM32F4_GPIO.h STM32F4_I2C.c STM32F4_I2C.h STM32F4_RCC.c STM32F4_RCC.h STM32F4_TIM.c STM32F4_TIM.h STM32F4_UART.c STM32F4_UART.h
  group Robot
    ./Robot/: Collision_avoidance.c Collision_avoidance.h Commands.c Commands.h Kinematics.c Manipulators.c Manipulators.h matrix.c matrix.h Regulator.c Regulator.h Robot.c Robot.h
  group Board
    ./Board/: Board.c Board.h Communication.c Communication.h Dynamixel_control.c Dynamixel_control.h Interrupts.c Interrupts.h VL6180x.c VL6180x.h
software components: CMSIS:CORE 5.0.1, Device:Startup 2.6.0
